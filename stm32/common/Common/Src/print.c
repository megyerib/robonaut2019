////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//!
//!  \file      print.c
//!  \brief
//!  \details
//!
////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

// Includes ------------------------------------------------------------------------------------------------------------

#include "print.h"

// Defines -------------------------------------------------------------------------------------------------------------

// Typedefs ------------------------------------------------------------------------------------------------------------

// Local (static) & extern variables -----------------------------------------------------------------------------------

// Local (static) function prototypes ----------------------------------------------------------------------------------

// Global function definitions -----------------------------------------------------------------------------------------

void print_uint32_t(uint32_t num, char* dst, int* len)
{
	if (num == 0)
	{
		dst[0] = '0';
	}
	else
	{
		int digits[10];
		int dnum = 0;
		int i;

		while (num > 0)
		{
			digits[dnum] = num % 10;
			num /= 10;
			dnum++;
		}

		for (i = 0; i < dnum; i++)
		{
			dst[i] = '0' + digits[dnum - 1 - i];
		}

		*len = dnum;
	}
}

// Local (static) function definitions ---------------------------------------------------------------------------------

// END -----------------------------------------------------------------------------------------------------------------
